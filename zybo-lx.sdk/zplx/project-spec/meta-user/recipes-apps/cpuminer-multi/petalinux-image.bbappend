IMAGE_INSTALL_append = " cpuminer-multi"
